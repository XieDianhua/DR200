# Keil uVision project differ_car_driver.uvprojx, settings and files
target FreeRTOS (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: differ_car_driver +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM3;..\CORE;..\STM32F10x_FWLib\inc;..\HARDWARE\ADC;..\HARDWARE\CAN;..\HARDWARE\USARTX;..\USER;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\SYSTEM;..\HARDWARE\MPU9250;..\HARDWARE\Robot_Select_Init;..\HARDWARE\show;..\HARDWARE\OLED;..\HARDWARE\LED;..\HARDWARE\IIC;..\HARDWARE\RELAY;..\HARDWARE\ULTRASOUND;..\HARDWARE\MOTIONCONTROL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group HARDWARE
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/CAN/: user_can.c can.c
    ../HARDWARE/USARTX/: usartx.c
    ../HARDWARE/SYSTEM/: system.c
    ../HARDWARE/show/: show.c
    ../HARDWARE/IIC/: IOI2C.c
    ../HARDWARE/LED/: LED.C
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/RELAY/: Relay_EN.c
    ../HARDWARE/ULTRASOUND/: ultrasound.c
    ../HARDWARE/MOTIONCONTROL/: MotionControl.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_can.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_i2c.c stm32f10x_bkp.c stm32f10x_pwr.c
  group FreeRTOS_PORTABLE
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/RVDS/ARM_CM3/: port.c
  group FreeRTOS_CORE
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group USER
    ../USER/: main.c stm32f10x_it.c system_stm32f10x.c
